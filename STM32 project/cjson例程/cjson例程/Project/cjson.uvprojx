# Keil uVision project cjson.uvprojx, settings and files
target cjson (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cjson
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\CORE;..\STM32F0_FWLib\inc;..\USER;..\STM32F0_FWLib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: cjson.c main.c Mcu_config.c stm32f0xx_it.c system_stm32f0xx.c
  group CORE
    ../CORE/: startup_stm32f030.s
  group FWLIB
    ../STM32F0_FWLib/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_usart.c
